# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_h7_tool.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,USE_USB_HS
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\fonts;..\..\User\images;..\..\User\app\inc;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\Libraries\LwIP\src\include;..\..\Libraries\LwIP\src\apps;..\..\Libraries\LwIP\system;..\..\Libraries\LwIP\phy_drv;..\..\User\lwip_if;..\..\User\lwip_http;..\..\User\lwip_tcp;..\..\Libraries\STM32_USB_Device_Library\Core\Inc;..\..\Libraries\STM32_USB_Device_Library\Class\MSC\Inc;..\..\User\modbus;..\..\User\programmer;..\..\User\lua\src;..\..\User\lua\if;..\..\User\usbd_mass_storage;..\..\User\usbd_virtual_com;..\..\Libraries\STM32_USB_Device_Library\Class\CDC\Inc;..\..\User\daplink\source\daplink\cmsis-dap;..\..\User\daplink\source\target;..\..\User\daplink\source\family\st\stm32h7;..\..\User\daplink\source\hic_hal;..\..\User\daplink\source\daplink;..\..\User\daplink\source\hic_hal\stm32\stm32h750;..\..\User\daplink\source\rtos_none;..\..\User\daplink\source\daplink\interface;..\..\User\daplink\source\daplink\settings;..\..\User\daplink\source\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group App
    ../../User/app/src/: main.c
    ../../User/bsp/: bsp_msg.h
    ../../User/app/inc/: main.h
  group BSP
    ../../User/bsp/: bsp.h bsp.c bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_user_lib.c bsp_timer.c bsp_led.c bsp_key.c bsp_tim_pwm.c bsp_tft_lcd.c bsp_tft_st7789.c bsp_period_ctrl.c bsp_cpu_flash.c bsp_qspi_w25q256.c
  group MDK-ARM
    ./: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_sdmmc.c stm32h7xx_hal_fdcan.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_hcd.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_pcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_nand.c stm32h7xx_hal_sai.c stm32h7xx_hal_eth.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_lptim.c stm32h7xx_hal_nor.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group CMSIS
    ../../User/bsp/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c asc62x40.c asc96x40.c
  group Images
    ../../User/images/: ADC.c Camera.c ChiLun.c chujiao.c FM.c GPS.c hwinfo.c images.h LCD.c MP3.c Phone.c radio.c Recorder.c USBDisk.c web.c Wireless.c
  group USB_Device_Library_Core
    ../../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_Device_Library_Class
    ../../Libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Libraries/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USBD_Virtual_COM
    ../../User/usbd_virtual_com/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_it.c usbd_user.c
  group USBD_Mass Storage
    ../../User/usbd_mass_storage/: usbd_conf.c usbd_desc.c usbd_it.c usbd_storage.c usbd_usr.c
  group Modbus
    ../../User/modbus/: modbus_slave.c modbus_register.c modbus_reg_addr.h
